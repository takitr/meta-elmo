require libshairplay.inc

DEPENDS += ""
LIC_FILES_CHKSUM="file://LICENSE;md5=7fff59c88f17faa814f26f26b06a7100"
PR = "r1"

SRC_URI[archive.md5sum] = "b009e0550c3cf54d740e92a5f47821e1"
SRC_URI[archive.sha256sum] = "61602402d846a50e8ddf82c3fb5b81984de95ed56abfe0f1e22426d1901c564f"
