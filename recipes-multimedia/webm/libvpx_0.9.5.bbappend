CONFIGUREOPTS = " \
          --target="armv6-linux-gcc" \
          --enable-vp8 \
          --enable-libs \
          --disable-install-docs \
          --prefix=${prefix} \
          --libdir=${libdir} \
"
